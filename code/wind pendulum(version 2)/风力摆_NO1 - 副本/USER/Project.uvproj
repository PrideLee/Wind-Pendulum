# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\CORE;..\USMART;..\0FreeRTOS\include;..\0FreeRTOS\portable\RVDS\ARM_CM4F;..\APP;..\HARDWARE\GPIO;..\HARDWARE\TIM\PWMOut8;..\HARDWARE\IIC;..\DRIVER\BEED;..\DRIVER\KEY;..\DRIVER\LED;..\Application;..\DRIVER\MPU6050;..\DRIVER\LCD;..\DRIVER\timer;..\DRIVER\attitude;..\DRIVER\PWMIn;..\DRIVER\PID
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Application
    ../Application/: APP.c Function.c Task1.c Task2.c Task3.c Task4.c Task5.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./: usart2.c
  group HARDWARE
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/TIM/PWMOut8/: PWMOut8.c
    ../HARDWARE/IIC/: myiic.c
    ../DRIVER/PWMIn/: PWMIN.c
  group DRIVER
    ../DRIVER/LED/: LED.c
    ../DRIVER/KEY/: KEY.c
    ../DRIVER/BEED/: BEED.c
    ../DRIVER/MPU6050/: MPU6050.c
    ../DRIVER/LCD/: lcd.c
    ../DRIVER/timer/: Timer.c
    ../DRIVER/attitude/: Attitude.c
    ../DRIVER/PID/: PID.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../0FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FreeRTOS_PORTABLE
    ../0FreeRTOS/portable/MemMang/: heap_4.c
    ../0FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group readme
    ./: readme.txt
